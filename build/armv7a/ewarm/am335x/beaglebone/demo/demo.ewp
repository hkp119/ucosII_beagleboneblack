# IAR project demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: am3359 TexasInstruments am3359
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: am335x; beaglebone
  ICCARM.CCDiagSuppress: Pa050, Pe1750, Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\include\; ..\..\..\..\..\..\include\hw\; ..\..\..\..\..\..\include\armv7a\; ..\..\..\..\..\..\include\armv7a\am335x\; ..\..\..\..\..\..\third_party\lwip-1.4.0\; ..\..\..\..\..\..\third_party\lwip-1.4.0\ports\cpsw\include\; ..\..\..\..\..\..\third_party\lwip-1.4.0\apps\httpserver_raw_io\; ..\..\..\..\..\..\examples\beaglebone\demo\; ..\..\..\..\..\..\third_party\lwip-1.4.0\src\include\; ..\..\..\..\..\..\third_party\lwip-1.4.0\src\include\ipv4\; ..\..\..\..\..\..\third_party\fatfs\src\; ..\..\..\..\..\..\mmcsdlib\include\; ..\..\..\..\..\..\third_party\lwip-1.4.0\src\include\lwip\; ..\..\..\..\..\..\third_party\lwip-1.4.0\apps\httpserver_raw_io\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: demo.bin
  postbuild: "..\..\..\..\..\..\tools\ti_image\tiimage.exe" "0x80000000" "NONE" "$TARGET_BPATH$.bin" "$TARGET_BPATH$_ti.bin"
  ILINK.IlinkOutputFile: demo.out
  ILINK.IlinkIcfFile: demo.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\binary\armv7a\ewarm\am335x\drivers\Debug\drivers.a; ..\..\..\..\..\..\binary\armv7a\ewarm\am335x\beaglebone\platform\Debug\platform.a; ..\..\..\..\..\..\binary\armv7a\ewarm\am335x\system_config\Debug\system.a; ..\..\..\..\..\..\binary\armv7a\ewarm\utils\Debug\utils.a; ..\..\..\..\..\..\binary\armv7a\ewarm\mmcsdlib\Debug\libmmcsd.a
  ILINK.IlinkProgramEntryLabel: Entry
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; am335x; beaglebone
  ICCARM.CCOptLevel: 3
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\binary\armv7a\ewarm\am335x\drivers\Release\drivers.a; ..\..\..\..\..\..\binary\armv7a\ewarm\am335x\beaglebone\platform\Release\platform.a; ..\..\..\..\..\..\binary\armv7a\ewarm\am335x\system_config\Release\system.a; ..\..\..\..\..\..\binary\armv7a\ewarm\utils\Release\utils.a; ..\..\..\..\..\..\binary\armv7a\ewarm\mmcsdlib\Release\libmmcsd.a
  group (top)
    ../../../../../../examples/beaglebone/demo/: demoDvfs.c demoEnet.c am335x_clock_data.c cm3wkup_proxy.c demoI2c.c demoPwrMgmnt.c pmic.c demoGpio.c demoLedIf.c demoMain.c demoRtc.c demoSdFs.c demoSdRw.c demoTimer.c demoUart.c
    ../../../../../../examples/evmAM335x/demo/: slpWkup_ewarm.S
    ../../../../../../third_party/fatfs/port/: fat_mmcsd.c
    ../../../../../../third_party/fatfs/src/: ff.c
    ../../../../../../third_party/lwip-1.4.0/apps/httpserver_raw_io/: httpd_io.c
    ../../../../../../third_party/lwip-1.4.0/ports/cpsw/: lwiplib.c
