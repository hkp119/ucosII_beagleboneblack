# IAR project usb_dev_msc.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: am3359 TexasInstruments am3359
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: am335x; am335x_15x15; DMA_MODE
  ICCARM.CCDiagSuppress: Pa050, Pe1750, Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\include\; ..\..\..\..\..\..\include\hw\; ..\..\..\..\..\..\usblib\include\; ..\..\..\..\..\..\include\armv7a\; ..\..\..\..\..\..\include\armv7a\am335x\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: usb_dev_msc.bin
  postbuild: "..\..\..\..\..\..\tools\ti_image\tiimage.exe" "0x80000000" "NONE" "$TARGET_BPATH$.bin" "$TARGET_BPATH$_ti.bin"
  ILINK.IlinkOutputFile: usb_dev_msc.out
  ILINK.IlinkIcfFile: usb_dev_msc.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\binary\armv7a\ewarm\am335x\drivers\Debug\drivers.a; ..\..\..\..\..\..\binary\armv7a\ewarm\am335x\beaglebone\platform\Debug\platform.a; ..\..\..\..\..\..\binary\armv7a\ewarm\am335x\system_config\Debug\system.a; ..\..\..\..\..\..\binary\armv7a\ewarm\utils\Debug\utils.a; ..\..\..\..\..\..\binary\armv7a\ewarm\am335x\usblib\Debug\usblib.a
  ILINK.IlinkProgramEntryLabel: Entry
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; am335x; beaglebone; DMA_MODE
  ICCARM.CCOptLevel: 3
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\binary\armv7a\ewarm\am335x\drivers\Release\drivers.a; ..\..\..\..\..\..\binary\armv7a\ewarm\am335x\beaglebone\platform\Release\platform.a; ..\..\..\..\..\..\binary\armv7a\ewarm\am335x\system_config\Release\system.a; ..\..\..\..\..\..\binary\armv7a\ewarm\utils\Release\utils.a; ..\..\..\..\..\..\binary\armv7a\ewarm\am335x\usblib\Release\usblib.a
  group (top)
    ../../../../../../examples/beaglebone/usb_dev_msc/: ramdisk.c usb_dev_msc.c usb_msc_structs.c usbdmscglue.c
