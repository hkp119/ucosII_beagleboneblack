# IAR project drivers.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: am3359 TexasInstruments am3359
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: am335x; am335x_15x15
  ICCARM.CCDiagSuppress: Pa050, Pe1750, Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\..\include\; ..\..\..\..\..\include\hw; ..\..\..\..\..\include\armv7a; ..\..\..\..\..\include\armv7a\am335x; ..\..\..\..\..\mmcsdlib\include; ..\..\..\..\..\grlib; ..\..\..\..\..\usblib\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; am335x; am335x_15x15
  ICCARM.CCOptLevel: 3
  group (top)
    ../../../../../drivers/: cppi41dma.c cpsw.c dcan.c dmtimer.c ecap.c edma.c ehrpwm.c elm.c gpio_v2.c gpmc.c hs_mmcsd.c hsi2c.c mailbox.c mcasp.c mcspi.c mdio.c phy.c raster.c rtc.c tsc_adc.c uart_irda_cir.c usb.c usbphyGS70.c watchdog.c
