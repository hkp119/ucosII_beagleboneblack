# IAR project demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: am3359 TexasInstruments am3359
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: am335x; evmAM335x
  ICCARM.CCDiagSuppress: Pa050, Pe1750, Pa082
  ICCARM.IExtraOptions: --separate_cluster_for_initialized_variables
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\include; ..\..\..\..\..\..\include\hw; ..\..\..\..\..\..\include; ..\..\..\..\..\..\include\armv7a; ..\..\..\..\..\..\include\armv7a\am335x; ..\..\..\..\..\..\third_party\lwip-1.4.0\src\include; ..\..\..\..\..\..\third_party\lwip-1.4.0\src\include\ipv4; ..\..\..\..\..\..\third_party\lwip-1.4.0\src\include\lwip; ..\..\..\..\..\..\third_party\lwip-1.4.0\ports\cpsw\include; ..\..\..\..\..\..\third_party\lwip-1.4.0\apps\httpserver_raw_io; ..\..\..\..\..\..\third_party\lwip-1.4.0\src\include\lwip; ..\..\..\..\..\..\third_party\lwip-1.4.0; ..\..\..\..\..\..\grlib\include; ..\..\..\..\..\..\examples\evmAM335x\demo; ..\..\..\..\..\..\third_party\lwip-1.4.0\src\include\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\..\..\..\include; ..\..\..\..\..\..\include\hw; ..\..\..\..\..\..\include; ..\..\..\..\..\..\include\armv7a\am335x
  OBJCOPY.OOCOutputFile: demo.bin
  postbuild: "..\..\..\..\..\..\tools\ti_image\tiimage.exe" "0x80000000" "NONE" "$TARGET_BPATH$.bin" "$TARGET_BPATH$_ti.bin"
  ILINK.IlinkOutputFile: demo.out
  ILINK.IlinkIcfFile: demo.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\binary\armv7a\ewarm\am335x\drivers\Debug\drivers.a; ..\..\..\..\..\..\binary\armv7a\ewarm\am335x\evmAM335x\platform\Debug\platform.a; ..\..\..\..\..\..\binary\armv7a\ewarm\am335x\system_config\Debug\system.a; ..\..\..\..\..\..\binary\armv7a\ewarm\utils\Debug\utils.a; ..\..\..\..\..\..\binary\armv7a\ewarm\mmcsdlib\Debug\libmmcsd.a; ..\..\..\..\..\..\binary\armv7a\ewarm\grlib\Debug\libgr.a; ..\..\..\..\..\..\binary\armv7a\ewarm\am335x\usblib\Debug\usblib.a; ..\..\..\..\..\..\binary\armv7a\ewarm\nandlib\Debug\nandlib.a
  ILINK.IlinkProgramEntryLabel: Entry
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; am335x; evmAM335x
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\include; ..\..\..\..\..\..\include\hw; ..\..\..\..\..\..\include; ..\..\..\..\..\..\include\armv7a; ..\..\..\..\..\..\include\armv7a\am335x; ..\..\..\..\..\..\third_party\lwip-1.4.0\src\include; ..\..\..\..\..\..\third_party\lwip-1.4.0\src\include\ipv4; ..\..\..\..\..\..\third_party\lwip-1.4.0\src\include\lwip; ..\..\..\..\..\..\third_party\lwip-1.4.0\ports\cpsw\include; ..\..\..\..\..\..\third_party\lwip-1.4.0\apps\httpserver_raw_io; ..\..\..\..\..\..\third_party\lwip-1.4.0\src\include\lwip; ..\..\..\..\..\..\third_party\lwip-1.4.0; ..\..\..\..\..\..\grlib\include; ..\..\..\..\..\..\examples\evmAM335x\demo; ..\..\..\..\..\..\third_party\lwip-1.4.0\src\include
  ICCARM.CCOptLevel: 3
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\binary\armv7a\ewarm\am335x\drivers\Release\drivers.a; ..\..\..\..\..\..\binary\armv7a\ewarm\am335x\evmAM335x\platform\Release\platform.a; ..\..\..\..\..\..\binary\armv7a\ewarm\am335x\system_config\Release\system.a; ..\..\..\..\..\..\binary\armv7a\ewarm\utils\Release\utils.a; ..\..\..\..\..\..\binary\armv7a\ewarm\mmcsdlib\Release\libmmcsd.a; ..\..\..\..\..\..\binary\armv7a\ewarm\grlib\Release\libgr.a; ..\..\..\..\..\..\binary\armv7a\ewarm\am335x\usblib\Release\usblib.a; ..\..\..\..\..\..\binary\armv7a\ewarm\nandlib\Release\nandlib.a
  group (top)
    ../../../../../../examples/evmAM335x/demo/: am335x_clock_data.c cm3wkup_proxy.c demoAccelerometer.c demoAic31.c demoCodecif.c demoDvfs.c demoEcap.c demoEnet.c demoGpio.c demoGrlib.c demoI2c.c demoMain.c demoPwrMgmnt.c demoRaster.c demoRtc.c demoTempSensor.c demoTimer.c demoToneLoop.c demoTouch.c demoUart.c pmic.c slpWkup_ewarm.S
    ../../../../../../third_party/lwip-1.4.0/apps/httpserver_raw_io/: httpd_io.c
    ../../../../../../third_party/lwip-1.4.0/ports/cpsw/: lwiplib.c
