# IAR project ehrpwm_haptics.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: am335x TexasInstruments am335x
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDiagSuppress: Pa050, Pe1750, Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\include; ..\..\..\..\..\..\include\hw; ..\..\..\..\..\..\include; ..\..\..\..\..\..\include\armv7a\am335x
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ehrpwm_haptics.bin
  postbuild: "..\..\..\..\..\..\tools\ti_image\tiimage.exe" "0x80000000" "NONE" "$TARGET_BPATH$.bin" "$TARGET_BPATH$_ti.bin"
  ILINK.IlinkOutputFile: ehrpwm_haptics.out
  ILINK.IlinkIcfFile: ehrpwm_haptics.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\binary\armv7a\ewarm\am335x\drivers\Debug\drivers.a; ..\..\..\..\..\..\binary\armv7a\ewarm\am335x\evmAM335x\platform\Debug\platform.a; ..\..\..\..\..\..\binary\armv7a\ewarm\am335x\system_config\Debug\system.a; ..\..\..\..\..\..\binary\armv7a\ewarm\utils\Debug\utils.a
  ILINK.IlinkProgramEntryLabel: Entry
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\binary\armv7a\ewarm\am335x\drivers\Release\drivers.a; ..\..\..\..\..\..\binary\armv7a\ewarm\am335x\evmAM335x\platform\Release\platform.a; ..\..\..\..\..\..\binary\armv7a\ewarm\am335x\system_config\Release\system.a; ..\..\..\..\..\..\binary\armv7a\ewarm\utils\Release\utils.a
  group (top)
    ../../../../../../examples/evmAM335x/ehrpwm_haptics/: ehrpwm_haptics.c
