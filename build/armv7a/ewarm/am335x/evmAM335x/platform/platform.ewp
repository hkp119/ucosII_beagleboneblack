# IAR project platform.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: am3359 TexasInstruments am3359
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: am335x; am335x_15x15; DMA_MODE
  ICCARM.CCDiagSuppress: Pa050, Pe1750, Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\include\; ..\..\..\..\..\..\include\hw; ..\..\..\..\..\..\include\armv7a; ..\..\..\..\..\..\include\armv7a\am335x; ..\..\..\..\..\..\mmcsdlib\include; ..\..\..\..\..\..\grlib; ..\..\..\..\..\..\usblib\include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; am335x; DMA_MODE
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\include\; ..\..\..\..\..\..\include\hw; ..\..\..\..\..\..\include\armv7a; ..\..\..\..\..\..\include\armv7a\am335x; ..\..\..\..\..\..\mmcsdlib\include; ..\..\..\..\..\..\usblib\include
  ICCARM.CCOptLevel: 3
  group (top)
    ../../../../../../platform/evmAM335x/: board.c cpld.c cpsw.c ctlregcontext.c dcan.c dmtimer.c edma.c eeprom.c gpio.c hs_mmcsd.c hsi2c.c lcd.c mcasp.c mcspi.c nand.c pwmss.c rtc.c sysdelay.c sysperf.c timertick.c tscAdc.c uart.c uartConsole.c usb.c watchdog.c
