# IAR project usb_host_mouse_msc.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: am3359 TexasInstruments am3359
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: am335x; am335x_15x15; DMA_MODE
  ICCARM.CCDiagSuppress: Pa050, Pe1750, Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\include; ..\..\..\..\..\..\include\hw; ..\..\..\..\..\..\include\armv7a\am335x; ..\..\..\..\..\..\usblib\include; ..\..\..\..\..\..\grlib\include; ..\..\..\..\..\..\include\armv7a; ..\..\..\..\..\..\third_party\fatfs\src
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\..\..\..\include; ..\..\..\..\..\..\include\hw; ..\..\..\..\..\..\include\armv7a; ..\..\..\..\..\..\include\armv7a\am335x; ..\..\..\..\..\..\usblib\include; ..\..\..\..\..\..\grlib\include
  OBJCOPY.OOCOutputFile: usb_host_mouse_msc.bin
  postbuild: "..\..\..\..\..\..\tools\ti_image\tiimage.exe" "0x80000000" "NONE" "$TARGET_BPATH$.bin" "$TARGET_BPATH$_ti.bin"
  ILINK.IlinkOutputFile: usb_host_mouse_msc.out
  ILINK.IlinkIcfFile: usb_host_mouse_msc.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\binary\armv7a\ewarm\am335x\drivers\Debug\drivers.a; ..\..\..\..\..\..\binary\armv7a\ewarm\am335x\evmAM335x\platform\Debug\platform.a; ..\..\..\..\..\..\binary\armv7a\ewarm\am335x\system_config\Debug\system.a; ..\..\..\..\..\..\binary\armv7a\ewarm\utils\Debug\utils.a; ..\..\..\..\..\..\binary\armv7a\ewarm\grlib\Debug\libgr.a; ..\..\..\..\..\..\binary\armv7a\ewarm\am335x\usblib\Debug\usblib.a
  ILINK.IlinkProgramEntryLabel: Entry
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; am335x; am335x_15x15; DMA_MODE
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\include; ..\..\..\..\..\..\include\hw; ..\..\..\..\..\..\include\armv7a\am335x; ..\..\..\..\..\..\grlib\include; ..\..\..\..\..\..\usblib\include; ..\..\..\..\..\..\include\armv7a; ..\..\..\..\..\..\third_party\fatfs\src
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: ..\..\..\..\..\..\include; ..\..\..\..\..\..\include\hw; ..\..\..\..\..\..\include\armv7a; ..\..\..\..\..\..\include\armv7a\am335x; ..\..\..\..\..\..\usblib\include; ..\..\..\..\..\..\grlib\include; ..\..\..\..\..\..\third_party\fatfs\src
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\binary\armv7a\ewarm\am335x\drivers\Release\drivers.a; ..\..\..\..\..\..\binary\armv7a\ewarm\am335x\evmAM335x\platform\Release\platform.a; ..\..\..\..\..\..\binary\armv7a\ewarm\am335x\system_config\Release\system.a; ..\..\..\..\..\..\binary\armv7a\ewarm\utils\Release\utils.a; ..\..\..\..\..\..\binary\armv7a\ewarm\grlib\Release\libgr.a; ..\..\..\..\..\..\binary\armv7a\ewarm\am335x\usblib\Release\usblib.a
  group (top)
    ../../../../../../third_party/fatfs/port/: fat_usbmsc.c
    ../../../../../../third_party/fatfs/src/: ff.c
    ../../../../../../examples/evmAM335x/usb_host_mouse_msc/: usb_host_mouse_msc.c
