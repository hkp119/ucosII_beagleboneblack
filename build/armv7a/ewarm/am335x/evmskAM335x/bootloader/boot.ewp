# IAR project boot.ewp, settings and files
configuration Debug_UART (ARM, debug)
  General.OGChipSelectEditMenu: am3359 TexasInstruments am3359
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: am335x; UART; evmskAM335x
  ICCARM.CCDiagSuppress: Pa050, Pe1750, Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\include; ..\..\..\..\..\..\include\hw; ..\..\..\..\..\..\include; ..\..\..\..\..\..\include\armv7a\; ..\..\..\..\..\..\include\armv7a\am335x; ..\..\..\..\..\..\bootloader\include; ..\..\..\..\..\..\mmcsdlib\include; ..\..\..\..\..\..\third_party\fatfs\src; ..\..\..\..\..\..\nandlib\include; ..\..\..\..\..\..\third_party\xmodem; ..\..\..\..\..\..\bootloader\include\armv7a\am335x
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\..\..\..\include; ..\..\..\..\..\..\include\hw; ..\..\..\..\..\..\include; ..\..\..\..\..\..\include\armv7a\am335x
  OBJCOPY.OOCOutputFile: boot.bin
  postbuild: "..\..\..\..\..\..\tools\ti_image\tiimage.exe" "0x402F0400" "UART" "$TARGET_BPATH$.bin" "$TARGET_BPATH$_ti.bin"
  ILINK.IlinkOutputFile: boot.out
  ILINK.IlinkIcfFile: boot.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\binary\armv7a\ewarm\am335x\drivers\Debug\drivers.a; ..\..\..\..\..\..\binary\armv7a\ewarm\am335x\evmskAM335x\platform\Debug\platform.a; ..\..\..\..\..\..\binary\armv7a\ewarm\am335x\system_config\Debug\system.a; ..\..\..\..\..\..\binary\armv7a\ewarm\utils\Debug\utils.a; ..\..\..\..\..\..\binary\armv7a\ewarm\mmcsdlib\Debug\libmmcsd.a
  ILINK.IlinkProgramEntryLabel: Entry
configuration Release_UART (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; am335x; UART; evmskAM335x
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\include; ..\..\..\..\..\..\include\hw; ..\..\..\..\..\..\include; ..\..\..\..\..\..\include\armv7a\; ..\..\..\..\..\..\include\armv7a\am335x; ..\..\..\..\..\..\bootloader\include; ..\..\..\..\..\..\mmcsdlib\include; ..\..\..\..\..\..\third_party\fatfs\src; ..\..\..\..\..\..\nandlib\include; ..\..\..\..\..\..\bootloader\include\armv7a\am335x
  ICCARM.CCOptLevel: 3
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\binary\armv7a\ewarm\am335x\drivers\Release\drivers.a; ..\..\..\..\..\..\binary\armv7a\ewarm\am335x\evmskAM335x\platform\Release\platform.a; ..\..\..\..\..\..\binary\armv7a\ewarm\am335x\system_config\Release\system.a; ..\..\..\..\..\..\binary\armv7a\ewarm\utils\Release\utils.a; ..\..\..\..\..\..\binary\armv7a\ewarm\mmcsdlib\Release\libmmcsd.a
configuration Debug_MMCSD (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: am335x; MMCSD; evmskAM335x
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\include; ..\..\..\..\..\..\include\hw; ..\..\..\..\..\..\include; ..\..\..\..\..\..\include\armv7a\am335x; ..\..\..\..\..\..\include\armv7a; ..\..\..\..\..\..\bootloader\include; ..\..\..\..\..\..\mmcsdlib\include; ..\..\..\..\..\..\third_party\fatfs\src; ..\..\..\..\..\..\nandlib\include; ..\..\..\..\..\..\third_party\xmodem; ..\..\..\..\..\..\bootloader\include\armv7a\am335x
  ICCARM.CCOptLevel: 1
  postbuild: "..\..\..\..\..\..\tools\ti_image\tiimage.exe" "0x402F0400" "MMCSD" "$TARGET_BPATH$.bin" "$TARGET_BPATH$_ti.bin"
configuration Release_MMCSD (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; am335x; MMCSD; evmskAM335x
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  postbuild: as above
  ILINK.IlinkAdditionalLibs: as above
  group (top)
    ../../../../../../bootloader/src/: bl_copy.c bl_hsmmcsd.c bl_main.c bl_mcspi.c bl_nand.c bl_nandgpmc.c bl_uart.c
    ../../../../../../bootloader/src/armv7a/ewarm/: bl_init.S
    ../../../../../../bootloader/src/armv7a/am335x/: bl_platform.c
    ../../../../../../system_config/armv7a/: cache.c mmu.c
    ../../../../../../system_config/armv7a/ewarm/: cp15.S
    ../../../../../../third_party/xmodem/: crc16.c xmodem.c
    ../../../../../../system_config/armv7a/am335x/: device.c
    ../../../../../../third_party/fatfs/port/: fat_mmcsd.c
    ../../../../../../third_party/fatfs/src/: ff.c
