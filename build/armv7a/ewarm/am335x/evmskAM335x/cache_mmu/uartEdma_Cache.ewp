# IAR project uartEdma_Cache.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: am3359 TexasInstruments am3359
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CACHE_FLUSH; am335x
  ICCARM.CCDiagSuppress: Pa050, Pe1750, Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\include; ..\..\..\..\..\..\include\hw; ..\..\..\..\..\..\include\armv7a; ..\..\..\..\..\..\include\armv7a\am335x
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: uartEdma_Cache_Cache.bin
  postbuild: "..\..\..\..\..\..\tools\ti_image\tiimage.exe" "0x80000000" "NONE" "$TARGET_BPATH$.bin" "$TARGET_BPATH$_ti.bin"
  ILINK.IlinkOutputFile: uartEdma_Cache_Cache.out
  ILINK.IlinkIcfFile: uartEdma_Cache.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\binary\armv7a\ewarm\am335x\drivers\Debug\drivers.a; ..\..\..\..\..\..\binary\armv7a\ewarm\am335x\evmAM335x\platform\Debug\platform.a; ..\..\..\..\..\..\binary\armv7a\ewarm\am335x\system_config\Debug\system.a; ..\..\..\..\..\..\binary\armv7a\ewarm\utils\Debug\utils.a
  ILINK.IlinkProgramEntryLabel: Entry
configuration Debug_flush (ARM, debug)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: uartEdma_Cache_CacheFlush.bin
  ILINK.IlinkOutputFile: uartEdma_Cache_CacheFlush.out
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\binary\armv7a\ewarm\am335x\drivers\Debug\drivers.a; ..\..\..\..\..\..\binary\armv7a\ewarm\am335x\evmskAM335x\platform\Debug\platform.a; ..\..\..\..\..\..\binary\armv7a\ewarm\am335x\system_config\Debug\system.a; ..\..\..\..\..\..\binary\armv7a\ewarm\utils\Debug\utils.a
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; am335x
  ICCARM.CCOptLevel: 3
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\binary\armv7a\ewarm\am335x\drivers\Release\drivers.a; ..\..\..\..\..\..\binary\armv7a\ewarm\am335x\evmskAM335x\platform\Release\platform.a; ..\..\..\..\..\..\binary\armv7a\ewarm\am335x\system_config\Release\system.a; ..\..\..\..\..\..\binary\armv7a\ewarm\utils\Release\utils.a
configuration Release_flush (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CACHE_CLEAN; am335x
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: uartEdma_Cache_CacheFlush.bin
  ILINK.IlinkOutputFile: uartEdma_Cache_CacheFlush.out
  ILINK.IlinkAdditionalLibs: as above
  group (top)
    ../../../../../../examples/evmskAM335x/cache_mmu/: uartEdma_Cache.c
