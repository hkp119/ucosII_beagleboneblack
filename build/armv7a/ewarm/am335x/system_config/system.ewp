# IAR project system.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: am3359 TexasInstruments am3359
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: am335x
  ICCARM.CCDiagSuppress: Pa050, Pe1750, Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\..\include\; ..\..\..\..\..\include\hw; ..\..\..\..\..\include\armv7a; ..\..\..\..\..\include\armv7a\am335x; ..\..\..\..\..\mmcsdlib\include; ..\..\..\..\..\grlib; ..\..\..\..\..\usblib\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; am335x; am335x_15x15
  ICCARM.CCOptLevel: 3
  group (top)
    ../../../../../system_config/armv7a/: cache.c mmu.c
    ../../../../../system_config/armv7a/am335x/: clock.c device.c interrupt.c startup.c
    ../../../../../system_config/armv7a/ewarm/: cp15.S cpu.S init.S
    ../../../../../system_config/armv7a/am335x/ewarm/: exceptionhandler.S
