# IAR project usblib.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: am3359 TexasInstruments am3359
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: am335x; am335x_15x15; DMA_MODE
  ICCARM.CCDiagSuppress: Pa050, Pe1750, Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\..\include\; ..\..\..\..\..\include\hw; ..\..\..\..\..\include\armv7a; ..\..\..\..\..\include\armv7a\am335x; ..\..\..\..\..\usblib\include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: am3358 TexasInstruments am3358
  ICCARM.CCDefines: NDEBUG; am335x; am335x_15x15; DMA_MODE
  ICCARM.CCIncludePath2: ..\..\..\..\..\include\; ..\..\..\..\..\include\hw; ..\..\..\..\..\include\armv7a; ..\..\..\..\..\include\armv7a\am335x; ..\..\..\..\..\mmcsdlib\include; ..\..\..\..\..\usblib\include
  ICCARM.CCOptLevel: 3
  group (top)
    ../../../../../usblib/: usbbuffer.c usbdata.c usbdesc.c usbkeyboardmap.c usbringbuf.c usbtick.c
    ../../../../../usblib/device/: usbdbulk.c usbdcdc.c usbdcdesc.c usbdcomp.c usbdconfig.c usbdenum.c usbdhandler.c usbdhid.c usbdhidmouse.c usbdmsc.c
    ../../../../../usblib/host/: usbhhid.c usbhhidkeyboard.c usbhhidmouse.c usbhmsc.c usbhostenum.c usbhscsi.c
