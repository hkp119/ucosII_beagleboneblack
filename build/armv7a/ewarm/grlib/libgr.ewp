# IAR project libgr.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDiagSuppress: Pa050, Pe1750, Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\include; ..\..\..\..\include\hw; ..\..\..\..\grlib\include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes:  ..\..\..\..\include;  ..\..\..\..\include\hw
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: utils.srec
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../../../grlib/: canvas.c checkbox.c circle.c container.c context.c image.c imgbutton.c line.c listbox.c offscr16bpp.c offscr1bpp.c offscr24bpp.c offscr4bpp.c offscr8bpp.c pushbutton.c radiobutton.c rectangle.c slider.c string.c widget.c
    ../../../../grlib/fonts/: fontcm12.c fontcm12b.c fontcm12i.c fontcm14.c fontcm14b.c fontcm14i.c fontcm16.c fontcm16b.c fontcm16i.c fontcm18.c fontcm18b.c fontcm18i.c fontcm20.c fontcm20b.c fontcm20i.c fontcm22.c fontcm22b.c fontcm22i.c fontcm24.c fontcm24b.c fontcm24i.c fontcm26.c fontcm26b.c fontcm26i.c fontcm28.c fontcm28b.c fontcm28i.c fontcm30.c fontcm30b.c fontcm30i.c fontcm32.c fontcm32b.c fontcm32i.c fontcm34.c fontcm34b.c fontcm34i.c fontcm36.c fontcm36b.c fontcm36i.c fontcm38.c fontcm38b.c fontcm38i.c fontcm40.c fontcm40b.c fontcm40i.c fontcm42.c fontcm42b.c fontcm42i.c fontcm44.c fontcm44b.c fontcm44i.c fontcm46.c fontcm46b.c fontcm46i.c fontcm48.c fontcm48b.c fontcm48i.c fontcmsc12.c fontcmsc14.c fontcmsc16.c fontcmsc18.c fontcmsc20.c fontcmsc22.c fontcmsc24.c fontcmsc26.c fontcmsc28.c fontcmsc30.c fontcmsc32.c fontcmsc34.c fontcmsc36.c fontcmsc38.c fontcmsc40.c fontcmsc42.c fontcmsc44.c fontcmsc46.c fontcmsc48.c fontcmss12.c fontcmss12b.c fontcmss12i.c fontcmss14.c fontcmss14b.c fontcmss14i.c fontcmss16.c fontcmss16b.c fontcmss16i.c fontcmss18.c fontcmss18b.c fontcmss18i.c fontcmss20.c fontcmss20b.c fontcmss20i.c fontcmss22.c fontcmss22b.c fontcmss22i.c fontcmss24.c fontcmss24b.c fontcmss24i.c fontcmss26.c fontcmss26b.c fontcmss26i.c fontcmss28.c fontcmss28b.c fontcmss28i.c fontcmss30.c fontcmss30b.c fontcmss30i.c fontcmss32.c fontcmss32b.c fontcmss32i.c fontcmss34.c fontcmss34b.c fontcmss34i.c fontcmss36.c fontcmss36b.c fontcmss36i.c fontcmss38.c fontcmss38b.c fontcmss38i.c fontcmss40.c fontcmss40b.c fontcmss40i.c fontcmss42.c fontcmss42b.c fontcmss42i.c fontcmss44.c fontcmss44b.c fontcmss44i.c fontcmss46.c fontcmss46b.c fontcmss46i.c fontcmss48.c fontcmss48b.c fontcmss48i.c fontcmtt12.c fontcmtt14.c fontcmtt16.c fontcmtt18.c fontcmtt20.c fontcmtt22.c fontcmtt24.c fontcmtt26.c fontcmtt28.c fontcmtt30.c fontcmtt32.c fontcmtt34.c fontcmtt36.c fontcmtt38.c fontcmtt40.c fontcmtt42.c fontcmtt44.c fontcmtt46.c fontcmtt48.c fontfixed6x8.c
