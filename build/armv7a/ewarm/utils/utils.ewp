# IAR project utils.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: am3359 TexasInstruments am3359
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDiagSuppress: Pa050, Pe1750, Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\include; ..\..\..\..\include\hw
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes:  ..\..\..\..\include;  ..\..\..\..\include\hw
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: ..\..\..\..\include\; ..\..\..\..\include\hw
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: utils.srec
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../../../utils/: ascii.c board.c cmdline.c delay.c misc.c perf.c systick.c uartStdio.c consoleUtils.c
